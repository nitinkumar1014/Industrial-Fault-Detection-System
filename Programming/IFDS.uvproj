# Keil uVision project IFDS.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: IFDS +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
  group Application
    ./: main.c
  group Drivers
    ./: Delay.c LCD_8Bit_Driver.c LED_Driver.c Switch_Driver.c Keypad_Driver.c I2C_Fields.c I2C_Frames.c MCP3204_Driver.c
